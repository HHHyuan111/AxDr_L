# Keil uVision project AxDr.uvprojx, settings and files
target AxDr (6230000::V6.23::.\ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AxDr +hex
  BeforeMake: python ..\..\..\tools\gen_build_id.py AxDr
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\User\adapter;..\User\app;..\User\common;..\User\config;..\User\control;..\User\diagnostic\include;..\User\drive;..\User\motor;..\User\bsp\inc;..\User\bsp;..\User\moldue\inc;..\User\algorithm;..\User\service;..\User\debug;..\User\debug\segger
  asm include: ;..\User\service
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: AxDr\AxDr.sct
  group User/app
    ../User/app/: control_cycle.c current_offset.c cycle_record.c fast_loop.c debug_snapshot.c
  group User/drive
    ../User/drive/: drive.c drive_command.c drive_diag.c drive_mode.c drive_protection.c drive_pwm.c drive_reset.c
  group User/control
    ../User/control/: control_cascade.c control_mit.c foc_control.c foc_core.c
    ../User/algorithm/: control_filter.c control_limit.c control_traj.c control_pid.c foc_svm.c foc_transform.c foc_smo.c
  group User/diagnostic/core
    ../User/diagnostic/core/: diag_runtime.c mc_bias_bandwidth.c mc_biased_l_ident.c mc_common.c mc_current_pi.c mc_current_sweep.c mc_deadtime_comp.c mc_deadtime_test.c mc_decoupling.c mc_diag_manager.c mc_encoder_alignment.c mc_flux_observer.c mc_param_ident.c mc_pole_pair_ident.c mc_rs_ident.c
  group User/bsp
    ../User/bsp/: target_adc.c target_encoder.c target_flash.c target_irq.c target_pwm.c target_qenc.c target_time.c target_reset.c
  group User/service
    ../User/service/: axdr_command_core.c axdr_safety_runtime.c service_usb.c service_usb_tx.c service_observation.c service_command.c service_telemetry.c service_scope.c service_param_store.c
  group User/config
    ../User/config/: motor_profile.c
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User/adapter
    ../User/adapter/: board_adapter.c encoder_adapter.c observer_adapter.c position_adapter.c speed_adapter.c
  group User/motor
    ../User/motor/: foc_drv.c foc_mapping.c motor_modes.c
  group User/modlue
    ../User/moldue/: display.c lcd.c
  group User/debug
    ../User/debug/: rtt_log.c
    ../User/debug/segger/: SEGGER_RTT.c
target AxDr-Debug (6230000::V6.23::.\ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: AxDr-Debug +hex
  BeforeMake: python ..\..\..\tools\gen_build_id.py AxDr-Debug
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: as above
  asm include: ;..\User\service
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: AxDr\AxDr.sct
software components: CMSIS:CORE 5.6.0
